# Keil uVision project RelayProject.uvproj, settings and files
target RelayProject (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: RelayProject +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: include;include\module
  group Platform
    ./: STARTUP.A51
  group Main
    ./main/: main.c interrupt.c
  group module
    ./main/module/wdg/: wdg.c
    ./main/module/tools/: tools.c
    ./main/module/led/: led.c
    ./main/module/timer/: timer.c
    ./main/module/keyboard/: keyboard.c
